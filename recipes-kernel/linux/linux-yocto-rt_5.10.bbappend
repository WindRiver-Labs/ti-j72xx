require linux-yocto-ti-j72xx.inc

KBRANCH_ti-j72xx  = "v5.10/standard/preempt-rt/ti-sdk-5.10/ti-j72xx"
