require linux-yocto-ti-j72xx.inc

KBRANCH_ti-j72xx  = "v5.10/standard/ti-sdk-5.10/ti-j72xx"

LINUX_VERSION_ti-j72xx ?= "5.10.x"
